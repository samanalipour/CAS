# Keil uVision project 04-02-2022.uvprojx, settings and files
target Target 1 (6180000::V6.18::ARMCLANG)
  device: LPC1768 NXP
  pack: Keil.LPC1700_DFP.2.7.1
  cpu: IRAM(0x10000000,0x8000) IRAM2(0x2007C000,0x8000) IROM(0x00000000,0x80000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: 04-02-2022
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  c include: .\ASM_func;.\Core;.\Peripherals;.\RTE
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x10000000 size 0x8000
  memory RVCT10: RAM 0x2007c000 size 0x8000
  group ASM_func
    ./ASM_func/: ASM_FUNCTION.s
  group Peripherals
    ./Peripherals/: button.h IRQ_button.c led.h lib_button.c lib_led.c
  group Core
    ./Core/: main.c main.h
software components: CMSIS:CORE 5.6.0, Device:Startup 1.0.0
