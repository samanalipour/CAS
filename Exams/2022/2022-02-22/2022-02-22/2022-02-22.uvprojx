# Keil uVision project 2022-02-22.uvprojx, settings and files
target Target 1 (6180000::V6.18::ARMCLANG)
  device: LPC1768 NXP
  pack: Keil.LPC1700_DFP.2.7.1
  cpu: IRAM(0x10000000,0x8000) IRAM2(0x2007C000,0x8000) IROM(0x00000000,0x80000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: 2022-02-22
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x10000000 size 0x8000
  memory RVCT10: RAM 0x2007c000 size 0x8000
  group ASM_func
    ./ASM_funs/: ASM_func.s
  group Core
    ./Core/: main.c main.h
software components: CMSIS:CORE 5.6.0, Device:Startup 1.0.0
