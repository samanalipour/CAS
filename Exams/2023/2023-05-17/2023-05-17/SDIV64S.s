U			RN	0
L			RN	1
D			RN	2
TMP1		RN	3
TMP2		RN	4
FLAG		RN	5
I			RN	6
Q			RN	7
OF			RN	8
			AREA MY_CODE,CODE,READONLY
SDIV64S		PROC
			EXPORT SDIV64S
			PUSH {R4-R8,LR}

			AND TMP1,U,#2_1000
			AND TMP2,D,#2_1000
			CMP TMP1,#0
			BEQ NOT_NEG
			MVN TMP1,U
			AND TMP1,#0X0000000F
			ADD TMP1,#1
			B CHECK_D
NOT_NEG
			MOV TMP1,U
CHECK_D
			CMP TMP2,#0
			BEQ NOT_NEG2
			MVN TMP2,D
			AND TMP2,#0X0000000F
			ADD TMP2,#1
			LSR TMP2,#1
			B CHECK_D2
NOT_NEG2
			MOV TMP2,D
			LSR TMP2,#1
CHECK_D2
			CMP TMP2,TMP1
			ITE HI
			LDRHI OF,=0
			LDRLS OF,=1

			AND TMP1,U,#2_1000
			AND TMP2,D,#2_1000
			CMP TMP1,TMP2
			ITE EQ
			LDREQ FLAG,=1
			LDRNE FLAG,=0
			AND TMP1,U,#2_1000
			CMP TMP1,#0
			BEQ DIVISOR_NEG
			MVN U,U
			MVN L,L
			AND U,#0X0000000F
			AND L,#0X0000000F
			ADD L,#1
			
DIVISOR_NEG
			AND TMP1,D,#2_1000
			CMP TMP1,#0
			CMP TMP1,#0
			BEQ FOR_LOOP
			MVN D,D
			AND D,#0X0000000F
			ADD D,#1
			
FOR_LOOP
			LDR I,=0
FOR			
			LSL U,#1 
			AND U,#2_01111
			LSL L,#1 
			MOV TMP1,L
			AND L,#2_01111
			AND TMP1,TMP1,#2_10000
			CMP TMP1,#0
			BEQ IF_U
			ORR U,#2_0001
IF_U
			CMP U,D
			BLO ELSE_U
			SUB U,D
			LDR TMP1,=3
			SUB TMP1,I
			LDR TMP2,=1
			LSL TMP2,TMP1
			ORR Q,TMP2
			B   NEXT
ELSE_U
			LDR TMP1,=3
			SUB TMP1,I
			LDR TMP2,=1
			LSL TMP2,TMP1
			MVN TMP2,TMP2
			AND Q,TMP2
NEXT
			ADD I,#1
			CMP I,#4
			BLO FOR
			CMP FLAG,#0
			BNE EXIT
			MVN Q,Q
			AND Q,#0X0000000F
			ADD Q,#1
EXIT
			MOV R0,Q
			MRS TMP1,XPSR
			MOV TMP2,Q
			AND TMP2,#2_1000
			CMP TMP2,#0
			ITE EQ
			ANDEQ TMP1,#0X7FFFFFFF
			ORRNE TMP1,#0X80000000
			CMP Q,#0
			ITE EQ
			ORREQ TMP1,#0X40000000
			ANDNE TMP1,#0XBFFFFFFF

			AND   TMP1,#0XDFFFFFFF
			CMP OF,#0
			ITE EQ
			ANDEQ TMP1,#0XEFFFFFFF
			ORRNE TMP1,#0X10000000
			MSR XPSR,TMP1
			POP {R4-R8,PC}
			ENDP
			END
				


