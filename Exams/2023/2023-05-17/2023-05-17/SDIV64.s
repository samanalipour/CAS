U			RN	0
L			RN	1
D			RN	2
TMP1		RN	3
TMP2		RN	4
FLAG		RN	5
I			RN	6
Q			RN	7
			AREA MY_CODE,CODE,READONLY
SDIV64		PROC
			EXPORT SDIV64
			PUSH {R4-R7,LR}
			
			AND TMP1,U,#2_1000
			AND TMP2,D,#2_1000
			CMP TMP1,TMP2
			ITE EQ
			LDREQ FLAG,=1
			LDRNE FLAG,=0
			
			
			AND TMP1,U,#2_1000
			CMP TMP1,#0
			BEQ DIVISOR_NEG
			MVN U,U
			MVN L,L
			AND U,#0X0000000F
			AND L,#0X0000000F
			ADD L,#1
			
DIVISOR_NEG
			AND TMP1,D,#2_1000
			CMP TMP1,#0
			CMP TMP1,#0
			BEQ FOR_LOOP
			MVN D,D
			AND D,#0X0000000F
			ADD D,#1
			
FOR_LOOP
			LDR I,=0
FOR			
			LSL U,#1 
			AND U,#2_01111
			LSL L,#1 
			MOV TMP1,L
			AND L,#2_01111
			AND TMP1,TMP1,#2_10000
			CMP TMP1,#0
			BEQ IF_U
			ORR U,#2_0001
IF_U
			CMP U,D
			BLO ELSE_U
			SUB U,D
			LDR TMP1,=3
			SUB TMP1,I
			LDR TMP2,=1
			LSL TMP2,TMP1
			ORR Q,TMP2
			B   NEXT
ELSE_U
			LDR TMP1,=3
			SUB TMP1,I
			LDR TMP2,=1
			LSL TMP2,TMP1
			MVN TMP2,TMP2
			AND Q,TMP2
NEXT
			ADD I,#1
			CMP I,#4
			BLO FOR
			CMP FLAG,#0
			BNE EXIT
			MVN Q,Q
			AND Q,#0X0000000F
			ADD Q,#1
EXIT
			MOV R0,Q
			POP {R4-R7,PC}
			ENDP
			END
				


