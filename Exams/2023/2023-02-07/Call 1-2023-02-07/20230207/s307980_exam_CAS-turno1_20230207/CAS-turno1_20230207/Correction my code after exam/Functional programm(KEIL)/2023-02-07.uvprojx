# Keil uVision project 2023-02-07.uvprojx, settings and files
target Target 1 (6180000::V6.18::ARMCLANG)
  device: LPC1768 NXP
  pack: Keil.LPC1700_DFP.2.7.1
  cpu: IRAM(0x10000000,0x8000) IRAM2(0x2007C000,0x8000) IROM(0x00000000,0x80000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: 2023-02-07
  c flags: Optim=2 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=2
  c include: .\Core;.\Peripherals;.\RTE
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x10000000 size 0x8000
  memory RVCT10: RAM 0x2007c000 size 0x8000
  group Core
    ./Core/: main.c
  group Peripherals
    ./Peripherals/: button.h IRQ_button.c IRQ_timer.c led.h lib_button.c lib_led.c lib_timer.c timer.h
software components: CMSIS:CORE 5.5.0, Device:Startup 1.0.0
