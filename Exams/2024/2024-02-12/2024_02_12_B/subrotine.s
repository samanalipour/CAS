ROW				RN	0
COL				RN	1
MAZE			RN	2
PATH			RN  3	
POINTER			RN	4
V				RN	5
WALL			RN	6
TMP_POINTER		RN	7
TMP				RN	8
FINAL_POS		RN	9
PATH_POINTER	RN  10
				AREA    example, CODE, READONLY
exploreMaze		PROC
				EXPORT exploreMaze
				PUSH 	{LR,R4-R11}
				LDR		PATH_POINTER,=0
				LDR		POINTER,=0
				ADD		POINTER,R1,#1
				MUL		FINAL_POS,COL,ROW
				SUB		FINAL_POS,#2
				SUB		FINAL_POS,COL
				LDR     V,='V'
				LDR 	WALL,='X'
				
				
SEC1			STRB	V,[MAZE,POINTER]			;SEC means section of question
SEC2			LDR		TMP,=0
				ADD		TMP_POINTER,POINTER,#1
				LDRB    TMP,[MAZE,TMP_POINTER]
				CMP     TMP,WALL
				BEQ		SEC3
				CMP		TMP,V
				BEQ		SEC3
				STRB	POINTER,[PATH,PATH_POINTER]
				ADD		PATH_POINTER,#1
				B		CHN_POINTER
				
SEC3			LDR		TMP,=0
				SUB		TMP_POINTER,POINTER,#1
				LDRB    TMP,[MAZE,TMP_POINTER]
				CMP     TMP,WALL
				BEQ		SEC4
				CMP		TMP,V
				BEQ		SEC4
				STRB	POINTER,[PATH,PATH_POINTER]
				ADD		PATH_POINTER,#1
				B		CHN_POINTER

SEC4			LDR		TMP,=0
				SUB		TMP_POINTER,POINTER,COL
				LDRB    TMP,[MAZE,TMP_POINTER]
				CMP     TMP,WALL
				BEQ		SEC5
				CMP		TMP,V
				BEQ		SEC5
				STRB	POINTER,[PATH,PATH_POINTER]
				ADD		PATH_POINTER,#1
				B		CHN_POINTER

SEC5			LDR		TMP,=0
				ADD		TMP_POINTER,POINTER,COL
				LDRB    TMP,[MAZE,TMP_POINTER]
				CMP     TMP,WALL
				BEQ		SEC6
				CMP		TMP,V
				BEQ		SEC6
				STRB	POINTER,[PATH,PATH_POINTER]
				ADD		PATH_POINTER,#1
				B		CHN_POINTER

SEC6			SUB		PATH_POINTER,#1
				CMP 	PATH_POINTER,#0
				BLT		RET0
				LDRB	POINTER,[PATH,PATH_POINTER]
				LDR     TMP,=0
				STRB	TMP,[PATH,PATH_POINTER]
				B		SEC7

RET0			LDR		R0,=0
				B		EXIT
				
CHN_POINTER		MOV POINTER,TMP_POINTER
SEC7			CMP POINTER,FINAL_POS
SEC8			BNE	SEC1
				STRB	POINTER,[PATH,PATH_POINTER]
				LDR	R0,=1

EXIT
				POP {PC,R4-R11}
				ENDP